# Keil uVision project powbridge.uvprojx, settings and files
target POWBRIDGE (6160000::V6.16::ARMCLANG)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: powbridge +hex
  c flags: Optim=1 OneElfS=1 wLevel=1
  c define: STM32F401xC,SBCPP,HSE_VALUE=25000000,HRDCPU=4
  c include: .\src\STM32F4xx_HAL_Driver\Inc;.\src\STM32F4xx_HAL_Driver;.\src\classes;..\..\..\..\..\MPULIBS;..\..\..\..\..\MPULIBS\mpustring;..\..\..\..\..\MPULIBS\ledindikator;..\..\..\..\..\MPULIBS\pwm;..\..\..\..\..\MPULIBS\ISTMCLASS
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group SRC
    ./src/: main.cpp
    ./src/classes/: TAIN.cpp TAWAVE.cpp TCORE.cpp TCORE_PROC.cpp
  group HALL
    ./src/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rtc_ex.c
    ./src/STM32F4xx_HAL_Driver/: startup_stm32f401xc.s system_stm32f4xx.c
  group LIBS
    ./src/classes/: hard_rut.cpp SYSBIOS.cpp rutine.cpp TFTASKIF.cpp ST7565R_SPI.CPP IEXTINT.cpp ITIMINT.cpp TEASYKEYS.cpp TM24Cxxx.cpp DISPATCHIFACE.CPP I2CSOFTWARE.CPP TGLOBALISR.cpp
    ./src/classes/fonts/: ptmono8.cpp
    ../../../../../MPULIBS/: TDRAWPARAM.cpp TPARAMCONTROL.cpp
    ../../../../../MPULIBS/mpustring/: STMSTRING.cpp
    ../../../../../MPULIBS/ledindikator/: LCD132x64.cpp
    ../../../../../MPULIBS/pwm/: TPWM.cpp
    ../../../../../MPULIBS/ISTMCLASS/: THBRIDGE.cpp
